Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:19+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-TRM-LABYRI
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Батут уличный, ZSK-TRM-LABYRI Батут «Лабиринт»
In: Площадка
Description: Батут уличный. Батут «Лабиринт»; Classification: 59.1.15.01-0817 Лабиринт (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-TRM-LABYRI; ModelReference: Батут «Лабиринт»; ProductionYear: 2026; ArticleNumber: ZSK-TRM-LABYRI
ORION_Изделие - Артикул: ZSK-TRM-LABYRI; Артикул прежний: SD-TRM-LABYRI; Наименование: Батут «Лабиринт»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Ø 3400 мм; Цена: 1 000 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/trampolines/30808; Код КСИ: CPr>EDB110; Класс КСИ: Лабиринт; Коды КСР: 59.1.15.01-0817 … 59.1.15.01-0838
ADSK - ADSK_Наименование: Батут «Лабиринт»; ADSK_Марка: ZSK-TRM-LABYRI; ADSK_Код изделия: 59.1.15.01-0817; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/trampolines/30808
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB110; ZSK_Артикул_прежний: SD-TRM-LABYRI
Qto_ORION - Длина: 3400 mm; Ширина: 3400 mm; Высота: 3400 mm
